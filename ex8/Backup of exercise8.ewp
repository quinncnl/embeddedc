# IAR project Backup of exercise8.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FG4619 MSP430FG4619
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430FG4619.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: lcd.c lcd.h lcd_ge8.c lcd_ge8.h main.c system.c system.h timer.c timer.h
